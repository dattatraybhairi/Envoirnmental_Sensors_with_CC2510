# IAR project per_test.ewp, settings and files
configuration Debug on CC1110 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: chip=1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\PER_TEST\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc1110F32.xcl
configuration Build .hex for CC1110 (8051)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration Debug on CC2510 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2510F32.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC2510_michelin_tag (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2510F32.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  XLINK.XclFile: as above
  group (top)
    ../code/Library/HAL/include/: ioCCxx10_bitdef.h
  group hal
    ../code/michelin_tag/: AXL.c bme280.c cc2510_spi.c per_test_dma.c per_test_main.c per_test_menu.c per_test_radio.c PM2Sleep.c timer3.c UART.c
    ../code/Library/HAL/source/: hal_adc_mgmt.c hal_power_clk_mgmt.c hal_wait.c
    $EW_DIR$/8051/inc/dlib/c/: stdint.h
    ../code/Library/HAL/include/: UART.h
  group hal_bui
    ../code/Library/HAL_BUI/source/: hal_bui_button.c hal_bui_joystick.c hal_bui_lcd.c
